# Repository 2201102/G474re_v2

File README.md:

G474reのロボット用メイン基板
# 機能
- ST-Link×1
- USART×1
- I2C×1
- CANFD×1
- USB×1
- エンコーダー×4
- モーター×4
- 汎用入出力×5

# USB書き込みの方法
BOOTボタンを押しながらリセットをすることでブートローダーが起動し、USB書き込みが行えるようになる。
CubeProgrammerでUSB接続を選択し、コンパイルした.elf/.binを書き込む

## KiCad design G474re_testboard_v2.kicad_pcb

Parts:
C1, C2: 10pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C1634
C3, C5, C9, C10, C11, C13, C14: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C14663
C6, C7, C12: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C15849
C8: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C19666
D1: LED_Y; LED_0805_2012Metric; LCSC C2296
J1: Conn_ST_STDC14; 3220-14-0100-00
J30: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
R1: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25803
R2: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22787
R7: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25804
SW1, SW2, SW3: SW_Push; SW_SPST_TS-1088-xR020; LCSC C720477
U1: STM32G474RETx; LQFP-64_10x10mm_P0.5mm; LCSC C521608
Y1: TSX-3225 24.0000MF20G-AC3; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C2650460

Connections:
+3V3: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, J1.3 (VCC), SW1.1, SW3.1, U1.1 (VBAT), U1.16 (VDD), U1.28 (VREF+), U1.29 (VDDA), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD); also elsewhere on the board
/G474/BOOT0: R7.1, SW3.2, U1.61 (PB8); also elsewhere on the board
/G474/CAN1_ON: U1.4 (PC15); also elsewhere on the board
/G474/FDCAN1_TX: U1.62 (PB9); also elsewhere on the board
/G474/FDCAN2_RX: U1.34 (PB12); also elsewhere on the board
/G474/FDCAN2_TX: U1.35 (PB13); also elsewhere on the board
/G474/I2C_SCL: U1.43 (PA9); also elsewhere on the board
/G474/I2C_SDA: U1.42 (PA8); also elsewhere on the board
/G474/USART1_RX: U1.23 (PC5); also elsewhere on the board
/G474/USART1_TX: U1.22 (PC4); also elsewhere on the board
/G474/USB_D+: U1.46 (PA12); also elsewhere on the board
/G474/USB_D-: U1.45 (PA11); also elsewhere on the board
/G474/encoder0_A: U1.59 (PB6); also elsewhere on the board
/G474/encoder0_B: U1.60 (PB7); also elsewhere on the board
/G474/encoder1_A: U1.8 (PC0); also elsewhere on the board
/G474/encoder1_B: U1.9 (PC1); also elsewhere on the board
/G474/encoder2_A: U1.38 (PC6); also elsewhere on the board
/G474/encoder2_B: U1.39 (PC7); also elsewhere on the board
/G474/encoder3_A: U1.26 (PB2); also elsewhere on the board
/G474/encoder3_B: U1.10 (PC2); also elsewhere on the board
/G474/motor0_Dig1: U1.21 (PA7); also elsewhere on the board
/G474/motor0_Dig2: U1.24 (PB0); also elsewhere on the board
/G474/motor0_PWM: U1.20 (PA6); also elsewhere on the board
/G474/motor1_Dig1: U1.12 (PA0); also elsewhere on the board
/G474/motor1_Dig2: U1.13 (PA1); also elsewhere on the board
/G474/motor1_PWM: U1.18 (PA4); also elsewhere on the board
/G474/motor2_Dig1: U1.33 (PB11); also elsewhere on the board
/G474/motor2_Dig2: U1.36 (PB14); also elsewhere on the board
/G474/motor2_PWM: U1.40 (PC8); also elsewhere on the board
/G474/motor3_Dig1: U1.44 (PA10); also elsewhere on the board
/G474/motor3_Dig2: U1.37 (PB15); also elsewhere on the board
/G474/motor3_PWM: U1.41 (PC9); also elsewhere on the board
/G474/sw0: U1.55 (PD2); also elsewhere on the board
/G474/sw1: U1.52 (PC10); also elsewhere on the board
/G474/sw2: U1.53 (PC11); also elsewhere on the board
/G474/sw3: U1.54 (PC12); also elsewhere on the board
/G474/sw4: U1.51 (PA15); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D1.1 (K), J1.5 (GND), J1.7 (GND), J1.11 (GNDDetect), J30.2, R1.2, R7.2, SW2.2, U1.15 (VSS), U1.27 (VSSA), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), Y1.2 (G), Y1.4 (G); also elsewhere on the board
NRST: C3.1, J1.12 (~RST), J30.4, SW2.1, U1.7 (PG10)
unnamed: D1.2 (A), R2.2
OSC_IN: C1.1, U1.5 (PF0), Y1.1
OSC_OUT: C2.1, U1.6 (PF1), Y1.3
T_SWCLK: J1.6 (JCLK/SWCLK), J30.1, U1.50 (PA14)
T_SWDIO: J1.4 (JTMS/SWDIO), J30.3, U1.49 (PA13)
T_SWO: J1.8 (JTDO/SWO), U1.56 (PB3)
T_VCP_RX: J1.13 (VCP_RX), U1.17 (PA3)
T_VCP_TX: J1.14 (VCP_TX), U1.14 (PA2)
USER_BUTTON: R1.1, SW1.2, U1.2 (PC13)
USER_LED: R2.1, U1.19 (PA5)

Notes on the sheet:
リセット
デバッグ用インターフェース
STM32G474RET6
ブート用
書き込みコネクタ
クロック

Parts:
C19, C20: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C19666
C21, C22, C23, C24: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C14663
D6: SS34; D_SMA; LCSC C8678
F1: PICOSMDC110S-2; Fuse_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV; LCSC PN C2988369
J3, J4, J18, J19, J20, J21, J22, J26, J27: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J5, J7, J8, J9, J14, J15, J16, J17, J23: Conn_01x04_Socket; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J6: Conn_01x08_Socket; JST_XH_S8B-XH-A_1x08_P2.50mm_Horizontal
J10: Conn_01x02_Pin; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J28: Conn_01x02_Socket; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
R5, R6: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC PN C23186
U4, U5: ATA6561; SOIC-8_3.9x4.9mm_P1.27mm
logo1: kosensai_logo

Connections:
+3V3: C24.1, J6.3, U5.5 (VIO); also elsewhere on the board
+5V: C19.1, C20.1, C21.1, C22.1, J6.1, J14.3, J15.3, J16.3, J17.3, J23.2, U4.3 (VCC), U5.3 (VCC); also elsewhere on the board
/G474/BOOT0: U4.4 (RXD); also elsewhere on the board
/G474/CAN1_ON: C23.1, U4.5 (VIO); also elsewhere on the board
/G474/FDCAN1_TX: U4.1 (TXD); also elsewhere on the board
/G474/FDCAN2_RX: U5.4 (RXD); also elsewhere on the board
/G474/FDCAN2_TX: U5.1 (TXD); also elsewhere on the board
/G474/I2C_SCL: J23.4; also elsewhere on the board
/G474/I2C_SDA: J23.3; also elsewhere on the board
/G474/USART1_RX: J6.5; also elsewhere on the board
/G474/USART1_TX: J6.6; also elsewhere on the board
/G474/USB_D+: J2.A6 (D+), J2.B6 (D+); also elsewhere on the board
/G474/USB_D-: J2.A7 (D-), J2.B7 (D-); also elsewhere on the board
/G474/encoder0_A: J14.2; also elsewhere on the board
/G474/encoder0_B: J14.4; also elsewhere on the board
/G474/encoder1_A: J15.2; also elsewhere on the board
/G474/encoder1_B: J15.4; also elsewhere on the board
/G474/encoder2_A: J16.2; also elsewhere on the board
/G474/encoder2_B: J16.4; also elsewhere on the board
/G474/encoder3_A: J17.2; also elsewhere on the board
/G474/encoder3_B: J17.4; also elsewhere on the board
/G474/motor0_Dig1: J5.4; also elsewhere on the board
/G474/motor0_Dig2: J5.2; also elsewhere on the board
/G474/motor0_PWM: J5.3; also elsewhere on the board
/G474/motor1_Dig1: J7.4; also elsewhere on the board
/G474/motor1_Dig2: J7.2; also elsewhere on the board
/G474/motor1_PWM: J7.3; also elsewhere on the board
/G474/motor2_Dig1: J8.4; also elsewhere on the board
/G474/motor2_Dig2: J8.2; also elsewhere on the board
/G474/motor2_PWM: J8.3; also elsewhere on the board
/G474/motor3_Dig1: J9.4; also elsewhere on the board
/G474/motor3_Dig2: J9.2; also elsewhere on the board
/G474/motor3_PWM: J9.3; also elsewhere on the board
/G474/sw0: J18.2; also elsewhere on the board
/G474/sw1: J19.2; also elsewhere on the board
/G474/sw2: J20.2; also elsewhere on the board
/G474/sw3: J21.2; also elsewhere on the board
/G474/sw4: J22.2; also elsewhere on the board
FDCAN1_H: J3.2, J26.2, U4.7 (CANH)
FDCAN1_L: J3.1, J26.1, U4.6 (CANL)
FDCAN2_H: J4.2, J27.2, U5.7 (CANH)
FDCAN2_L: J4.1, J27.1, U5.6 (CANL)
GND: C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), J5.1, J6.2, J7.1, J8.1, J9.1, J10.1, J14.1, J15.1, J16.1, J17.1, J18.1, J19.1, J20.1, J21.1, J22.1, J23.1, J28.1, R5.1, R6.1, U4.2 (GND), U4.8 (STB), U5.2 (GND), U5.8 (STB); also elsewhere on the board
unnamed: D6.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: D6.1 (K), F1.1
unnamed: J2.A5 (CC1), R6.2
unnamed: J2.B5 (CC2), R5.2
VBUS: F1.2; also elsewhere on the board
VCC: J10.2, J28.2; also elsewhere on the board

Parts:
C15: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC PN C19702
C16: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C96446
C17: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC PN C19702
C18: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C45783
D3: SS34; D_SMA; LCSC C8678
D4: LED_G; LED_0805_2012Metric; LCSC C2297
D5: LED_W; LED_0805_2012Metric; LCSC C34499
R3, R4: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C22787
SW4: SW_SPDT; IS-1235-G
U2: AMS1117-5.0; SOT-223-3_TabPin2; LCSC C6187
U3: AMS1117-3.3; SOT-223-3_TabPin2; LCSC C6186

Connections:
+3V3: C18.1, R4.1, U3.2 (VO); also elsewhere on the board
+5V: C16.1, R3.1, SW4.2 (B), U3.3 (VI); also elsewhere on the board
+5VD: C17.2, D3.2 (A), SW4.3 (C), U2.2 (VO)
GND: C15.2, C16.2, C17.1, C18.2, D4.1 (K), D5.1 (K), U2.1 (GND), U3.1 (GND); also elsewhere on the board
unnamed: D4.2 (A), R3.2
unnamed: D5.2 (A), R4.2
VBUS: SW4.1 (A); also elsewhere on the board
VCC: C15.1, D3.1 (K), U2.3 (VI); also elsewhere on the board

Board: 2 copper layers, 82.0 x 82.0 mm, 75 parts (9 on the bottom side), 63 nets.

## Code that names these connections

File g474re_testboard_v2.ioc (part):

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Mcu.Name=STM32G474R(B-C-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32G474RETx
PA0.Signal=GPIO_Output
PA1.Signal=GPIO_Output
PA10.Signal=GPIO_Output
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.Signal=S_TIM2_CH1
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.Signal=S_TIM3_CH2
PA5.Signal=GPIO_Output
PA6.Signal=S_TIM3_CH1
PA7.Signal=GPIO_Output
PA8.Mode=I2C
PA8.Signal=I2C2_SDA
PA9.Mode=I2C
PA9.Signal=I2C2_SCL
PB0.Signal=GPIO_Output
PB11.Signal=GPIO_Output
PB12.Mode=FDCAN_Activate
PB12.Signal=FDCAN2_RX
PB13.Mode=FDCAN_Activate
PB13.Signal=FDCAN2_TX
PB14.Signal=GPIO_Output
PB15.Signal=GPIO_Output
PB2.Signal=S_TIM20_CH1
PB3.Signal=SYS_JTDO-SWO
PB6.Signal=S_TIM4_CH1
PB7.Signal=S_TIM4_CH2
PB8-BOOT0.Mode=FDCAN_Activate
PB8-BOOT0.Signal=FDCAN1_RX
PB9.Mode=FDCAN_Activate
PB9.Signal=FDCAN1_TX
PC0.Signal=S_TIM1_CH1
PC1.Signal=S_TIM1_CH2
PC10.Signal=GPIO_Input
PC11.Signal=GPIO_Input
PC12.Signal=GPIO_Input
PC13.Signal=GPIO_Input
PC15-OSC32_OUT.Signal=GPIO_Output
PC2.Signal=S_TIM20_CH2
PC4.Mode=Asynchronous
PC4.Signal=USART1_TX
PC5.Mode=Asynchronous
PC5.Signal=USART1_RX
PC6.Signal=S_TIM8_CH1
PC7.Signal=S_TIM8_CH2
PC8.Signal=S_TIM3_CH3
PC9.Signal=S_TIM3_CH4
PD2.Signal=GPIO_Output
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

## Commit log

2026-05-14 upload
2026-05-14 Add title for main board in README
2026-05-14 修正テスト
2026-05-16 kicad10.0.3test
2026-05-16 iocファイルを追加
2026-05-16 Update README with features and USB programming steps
    Added features and USB programming instructions.
2026-05-19 余計な抵抗を削除
2026-06-24 変更テスト
